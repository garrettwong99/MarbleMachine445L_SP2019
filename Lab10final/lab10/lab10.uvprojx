# Keil uVision project lab10.uvprojx, settings and files
target Blynk (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Blynk
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: rvmdk PART_LM4F120H5QR
  c misc: --C99
  c include: ..;..\..\..
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./: startup.s PLL.c UART.c PortF.c esp8266.c esp8266.h
    ../inc/: Timer0A.c ST7735.c Timer4A.c Timer5A.c Timer2A.c Timer3A.c
    ../../lab11/ee445l-final-project-gcw496_jas23823_tf6693_rb42554/Lab10_SourceFiles/: Lab10_Main.c MotorControl.c PWM.c PWM.h InputCapture.c InputCapture.h
software components: CMSIS:CORE 5.0.2
